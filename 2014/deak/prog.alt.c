#include <stdio.h>
#ifndef X1
#define X1 -2
#endif
#ifndef X2
#define X2 1
#endif
#ifndef Y1
#define Y1 -1.3
#endif
#ifndef Y2
#define Y2 1.3
#endif
double                                 _[]={X1
,X2,Y1                ,Y2,  0,           0,0,0
,0               ,0,50, 80,     0,0,0     ,255
,               8,0};    int      main       (
	       int j) {if (j==  1 ){ if(
       _[12]      >_[10]  )_[17]=1 ;}  if
   (_[13] >_[11     ] ||_[17]==1)  return 1
 ;_[6]   =  _ [13] / _[11]*(_[1]-_[   0])
+_[  0];  _ [7]=_[12]/_[10]*(_[3]-_[2] )+_
[2];_[8]=_[9]=_[14]=0;l2:_[4]=_[8] * _ [8]
;_[  5]=  _ [9]*_[9];_[9]=2*_[8]*_[9]+ _[7
 ];_[8   ]  = _ [ 4 ]-_[5]+_[6];_[14   ]++
   ;if((_ [14]<     _ [15])&&(_[4]+ _[ 5]
       <_[16      ])) goto l2;  putchar(
	       " #@*+   "[( int)  _[14]%
5             ]);_ [13   ] ++ ;   main       (
0)               ;_[12]++;      _[13]       =0
;if(_                [17]    !=1)      putchar
(0xa);                               main(1);}

