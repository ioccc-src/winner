#  include<stdio.h>//  .IOCCC                                         Fluid-  #
#  include <unistd.h>  //2012                                         _Sim!_  #
#  include<complex.h>  //||||                     ,____.              ||||||  #
#  define              c y+=(                    x=ctanh(            -cabs/*  #
#  */(4[t              ]-=20)                     /2+9)*             3+3)*//  #
#  define              f(p,e)                                        for(p/*  #
#  */=a;e              ,p<r;p                                        +=5)///  #
#  define              z(e,i)                                        f(p,p/*  #
## */[i]=e)f(q,w=cabs  (d=*p-  *q)/2-     1)if(0  <(x=1-      w))p[i]+=w*/// ##
   double complex a [  97687]  ,*p,*q     ,*r=a,  w=0,d;    char b[97687]=/* ##
## */"GO\x1b[2J\x1b["  "1;1H"  ,*o=b,     *t;int  x,y,j;   void h(int e){/** ##
## */for(              t=b;b+  24045>     (t+=12  );c 6,  sprintf     (t,/** ##
## */"%c"              "[48%"  "c5;%"     "03dm"  "%c",3  *9,e,c      36,e/* ##
## */?(t-              b)%960  ?(15-t     [11])[  "\x23"  "/\\_"      "\\"/* ##
## */"||"              ",//|"  ".-`'      "]:10:  0)) y=  0020,c      01;}/* ##
## */void              g( int  i){7[t     +=i]|=  x/=2;*  t+=y=p      [2];/* ##
## */}int              main()  {for(;(    x=getc  (stdin  ))>0;)w     =10</* ##
## */x?32              <x?4[*   r++=w,r]=w+1,*r=  r[5]=x   ==35,r+=9:0,w-I/* ##
## */:(x=              w+02);    for(;;puts(o),o  =b+6){    z(p[1]*9,2)w;z/* ##
## */(G,3              )(d*(3      -p[2]-q[2])*P  +p[4]*      V-q[4]*V )/p/* ##
####                                                                       ####
###############################################################################
**###########################################################################*/

         [2];h(0       );f(p,*     p+=           p[4]+=p     [3]/10*!p
       [1]     )(t   =b+     16+   (x=         *p*     I)*   12+     960
       *(y           =*p     /2)   ,x=         0<=     x&&   79>     x&&
       0<=           y&&     23>   y?x         =16     ,g(   0),g(12),
       g(+     948   ),g     (12   ),0         :0)     ;h(   59)     ;;;
         usleep(       12321);     }return 0;}   /*IOCCC     '12     **/
