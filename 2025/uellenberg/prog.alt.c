#include<stdio.h>

/* IOCCC29, w = up, e = down */

int a= 32 ; int b= 6 ; int c= -1 ; int d= 1 ; int e= 5 ; int f= 10 ; int g= 62 ; int h= 5 ; int i[6]={ 1,3,1,4,1,0} ; char*j[]={  "\
\
#include<stdio.h>''/*$IOCCC29,$w$=$up,$e$=$down$*/''int$a=","32",";int\
$b=","6",";int$c=","-1",";int$d=","1",";int$e=","5",";int$f=","10",";i\
nt$g=","62",";int$h=","5",";int$i[6]={1,3,1,4,1,0};char*j[]={","","};i\
nt$k=0;int$l=1;int$m(){'$$$$l++;'$$$$if(l==1)return!putchar(44);'$$$$i\
f(l==2)return!putchar(34);'$$$$char$o=j[k][l-3];'$$$$if(!o){'$$$$$$$$l\
=0;'$   $$$$$$$k++;'$$$$$$$$return!putchar(34);'$$$$}'$$$$if(o   ==34)\
{'$$$   $$$$$putchar(92);'$$$$$$   $$return$putchar(34);'$$$$}   '$$$$\
if(o=   =92){'$$$$$$$$putchar(92   );'$$$$$$$$return$putchar(9   2);'$\
$$$}'   $$$$if(o!=32&&o!=10)return!putchar(o);'$$$$return$m();   '}'vo\
id$n(   int$o,int$p){'$$$$asprintf(j+o,\"%i\",p);'}'int$main(i   nt$o,\
char**p){'$$$$char*q;'$$$$if(c<2)a+=c;'$$$$b+=d;'$$$$int$r=b+2>f/2&&b<\
f/2+5;'$$$$int$s=a+2==g&&b+2>h&&b<h+5;'$$$$if(c<2){'$$$$$$$$if(a==e+2&\
&r||s){'$$$$$$$$$$$$a-=c;'$$$$$$$$$$$$b-=d;'$$$$$$$$$$$$c=-c;'$$$$$$$$\
}'$$$$$$$$if(a<0||a>67){'$$$$$$$$$$$$if(a<0){'$$$$$$$$$$$$$$$$c=2;'$$$\
$$$$$$$$$$$$$d=0;'$$$$$$$$$$$$}'$$$$$$$$$$$$a=34;'$$$$$$$$$$$$b=6;'$$$\
\
$$$$$}'$$$$$$$$if(b<0||b>13){'$$$$$$$$$$$$b-=d;'$$$$$$$$$$$$d=-d;'$$$$$$$$}'$$$$$$$$if(f/2>10)f-=2;'$$$$$$$$if(h>10)h--;'$$$$$$$$if(o>1){'$$$$$$$$$$$$if(*p[1]==119&&h>0)h--;'$$$$$$$$$$$$if(*p[1]==101&&h<10)h++;'$$$$$$$$}'$$$$$$$$s=f/2-b+1;'$$$$$$$$if(s<0)f++;'$$$$$$$$if(s>0)f--;'$$$$}'$$$$else{'$$$$$$$$b++;'$$$$$$$$if(d<0)d++;'$$$$$$$$if(b>=13){'$$$$$$$$$$$$if(o>1&&*p[1]==119)d=-4;'$$$$$$$$$$$$b=13;'$$$$$$$$}'$$$$$$$$if(f/2<15-i[c-2])f+=2;'$$$$$$$$else$e--;'$$$$$$$$if(h<15-i[c-1])h++;'$$$$$$$$else$g--;'$$$$$$$$if(e+3<=0){'$$$$$$$$$$$$c++;'$$$$$$$$$$$$if(c<7){'$$$$$$$$$$$$$$$$e=g;'$$$$$$$$$$$$$$$$f=h*2;'$$$$$$$$$$$$$$$$g=70;'$$$$$$$$$$$$$$$$h=15-i[c-1];'$$$$$$$$$$$$}'$$$$$$$$$$$$else{'$$$$$$$$$$$$$$$$e=5;'$$$$$$$$$$$$$$$$g=62;'$$$$$$$$$$$$$$$$c=1;'$$$$$$$$$$$$$$$$d=1;'$$$$$$$$$$$$}'$$$$$$$$}'$$$$$$$$if(a+2==e&&r||s){'$$$$$$$$$$$$c=2;'$$$$$$$$$$$$e=5;'$$$$$$$$$$$$f=28;'$$$$$$$$$$$$g=62;'$$$$$$$$$$$$h=12;'$$$$$$$$}'$$$$}'$$$$n(1,a);'$$$$n(3,b);'$$$$n(5,c);'$$$$n(7,d);'$$$$n(9,e);'$$$$n(11,f);'$$$$n(13,g);'$$$$n(15,h);'$$$$for(s=0;s<","29",";s++){'$$$$$$$$if(s)putchar(32);'$$$$$$$$q=j[s];'$$$$$$$$r=1;'$$$$$$$$for(char*t=q;*t;t++)if(*t==","36",")putchar(32);'$$$$$$$$else$if(*t==","39",")putchar(10);'$$$$$$$$else$if(*t!=32&&*t!=10){'$$$$$$$$$$$$r=0;'$$$$$$$$$$$$putchar(*t);'$$$$$$$$$$$$if(*t==123||*t==125||*t==59)putchar(32);'$$$$$$$$}'$$$$$$$$if(r){'$$$$$$$$$$$$m();'$$$$$$$$$$$$putchar(92);'$$$$$$$$$$$$putchar(10);'$$$$$$$$$$$$putchar(92);'$$$$$$$$$$$$putchar(10);'$$$$$$$$$$$$for(o=0;o<15;o++){'$$$$$$$$$$$$$$$$for(int$u=0;u<70;u++)if(k>=","29","||u>=a&&o>=b&&u-a<3&&o-b<2||u>=e&&o>=f/2&&u-e<3&&o-f/2<5||u>=g&&o>=h&&u-g<3&&o-h<5)putchar(32);'$$$$$$$$$$$$$$$$else$if(m())u++;'$$$$$$$$$$$$$$$$if(l)putchar(92);'$$$$$$$$$$$$$$$$putchar(10);'$$$$$$$$$$$$}'$$$$$$$$$$$$if(l)putchar(92);'$$$$$$$$$$$$putchar(10);'$$$$$$$$$$$$for(;k<","29",";)m();'$$$$$$$$}'$$$$}'$$$$putchar(10);'}'" } ; int k=0; int l=1; int m(){
    l++;
    if(l==1)return!putchar(44);
    if(l==2)return!putchar(34);
    char o=j[k][l-3];
    if(!o){
        l=0;
        k++;
        return!putchar(34);
    }
    if(o==34){
        putchar(92);
        return putchar(34);
    }
    if(o==92){
        putchar(92);
        return putchar(92);
    }
    if(o!=32&&o!=10)return!putchar(o);
    return m();
}
void n(int o,int p){
    asprintf(j+o,"%i",p);
}
int main(int o,char**p){
    char*q;
    if(c<2)a+=c;
    b+=d;
    int r=b+2>f/2&&b<f/2+5;
    int s=a+2==g&&b+2>h&&b<h+5;
    if(c<2){
        if(a==e+2&&r||s){
            a-=c;
            b-=d;
            c=-c;
        }
        if(a<0||a>67){
            if(a<0){
                c=2;
                d=0;
            }
            a=34;
            b=6;
        }
        if(b<0||b>13){
            b-=d;
            d=-d;
        }
        if(f/2>10)f-=2;
        if(h>10)h--;
        if(o>1){
            if(*p[1]==119&&h>0)h--;
            if(*p[1]==101&&h<10)h++;
        }
        s=f/2-b+1;
        if(s<0)f++;
        if(s>0)f--;
    }
    else{
        b++;
        if(d<0)d++;
        if(b>=13){
            if(o>1&&*p[1]==119)d=-4;
            b=13;
        }
        if(f/2<15-i[c-2])f+=2;
        else e--;
        if(h<15-i[c-1])h++;
        else g--;
        if(e+3<=0){
            c++;
            if(c<7){
                e=g;
                f=h*2;
                g=70;
                h=15-i[c-1];
            }
            else{
                e=5;
                g=62;
                c=1;
                d=1;
            }
        }
        if(a+2==e&&r||s){
            c=2;
            e=5;
            f=28;
            g=62;
            h=12;
        }
    }
    n(1,a);
    n(3,b);
    n(5,c);
    n(7,d);
    n(9,e);
    n(11,f);
    n(13,g);
    n(15,h);
    for(s=0; s< 29 ; s++){
        if(s)putchar(32);
        q=j[s];
        r=1;
        for(char*t=q; *t; t++)if(*t== 36 )putchar(32);
        else if(*t== 39 )putchar(10);
        else if(*t!=32&&*t!=10){
            r=0;
            putchar(*t);
            if(*t==123||*t==125||*t==59)putchar(32);
        }
        if(r){
            m();
            putchar(92);
            putchar(10);
            putchar(92);
            putchar(10);
            for(o=0; o<15; o++){
                for(int u=0; u<70; u++)if(k>= 29 ||u>=a&&o>=b&&u-a<3&&o-b<2||u>=e&&o>=f/2&&u-e<3&&o-f/2<5||u>=g&&o>=h&&u-g<3&&o-h<5)putchar(32);
                else if(m())u++;
                if(l)putchar(92);
                putchar(10);
            }
            if(l)putchar(92);
            putchar(10);
            for(; k< 29 ; )m();
        }
    }
    putchar(10);
}

